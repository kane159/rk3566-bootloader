## configs/rk3566_miyoo_defconfig
```kconfig
CONFIG_SPL=y
CONFIG_BOOTDELAY=3
CONFIG_BOOTCOMMAND="bootmenu"
CONFIG_BOOTMENU=y
CONFIG_BOOTMENU_ENABLE_TIMEOUT=1
```
